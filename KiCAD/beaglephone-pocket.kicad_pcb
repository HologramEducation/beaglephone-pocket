# Repository HologramEducation/beaglephone-pocket

File README.md:

# Beaglephone-Pocket 

## Background

This is a clone of the [Hologram Nova](https://github.com/hologram-io/nova-hardware), refactored to work with the [Pocket Beagle from the Beagleboard.org foundation](https://github.com/jadonk/pocketbeagle).

### License

This design is OSHW

## Usage

This device is meant to work with uBlox cellular modems and the Hologram Global SIM card. To get a free SIM and 1 MB of data per month on the cellular plan, check out the [Developer Plan](https://hologram.io/devplan/)

## KiCad design KiCAD/beaglephone-pocket.kicad_pcb

Parts:
ANT1: A-1JB; MPN A-1JB
C1: 10u; C_0603; MPN GRM188R60J106ME84D
C2: 100n; C_0402; MPN GRM155R61C104KA88D
C3, C4, C5, C8, C10, C11, C15: NOPE; C_0402; MPN NULL
C6: 2.2U; C_0603; MPN CL10A225MQ8NNNC
C7, C9, C12, C21, C27: 22U; C_0603; MPN GRM188R60J226MEA0D
C13, C14, C22: 330U; C_1210; MPN F950J337MBAAQ2
C16: 0.1U; C_0402; MPN CL05B104KO5NNNC
C17, C18, C19, C20: 47p; C_0402; MPN GRM1555C1H470JA01
C23: 10n; C_0402; MPN GRM1555C1H100JA01D
C24: 100n; C_0402; MPN GRM155R71C104KA88J
C25: 56p; C_0402; MPN GRM1555C1H560JA01D
C26: 15p; C_0402; MPN GJM1555C1H150JB01D
D1: Red LED; LED_0402; MPN VLMS1500-GS08
D2, D3, D4, D10, D11, D12, D13: PESD0402; R_0402; MPN PESD0402-140
D5, D6, D7, D8: MBR052; D_SOD-123; MPN MBR0520LT1G
D9: Blue LED; LED_0402; MPN VLMB1500-GS08
J1, J2: Conn_01x02; Pin_Header_Straight_1x02_Pitch2.54mm; MPN 61300211121
J3: USB_OTG; USB_Micro-B; MPN 10118194-0001LF
L1: 1uH; XFL4020; MPN XFL4020-102MEC
L2: NOPE; L_0402; MPN NULL
L3: FB; R_0603; MPN BLM18AG121SN1D
P1, P2: PB_CONN; TH-2X18-(35MIL-DIA)-W_O-SILK; MPN PocketBeagle_Connectors
Q1, Q2, Q3, Q4: 2N3904; SOT-23; MPN MMBT3904L
Q5, Q6, Q7, Q8: Q_NMOS_GSD; SOT-23; MPN 2N7002
R1, R6, R7, R14, R39, R40, R42, R43, R44, R45, R46, R47: 10K; R_0402; MPN RC0402JR-0710KL
R2, R3, R4, R8, R9, R15, R26, R28, R29: 0; R_0402; MPN RC0402JR-070RL
R5, R20: 3K; R_0402; MPN RC0402JR-073KL
R10, R17, R18, R19, R21, R22, R23, R24, R27, R34, R35, R36, R37, R38: NOPE; R_0402; MPN NULL
R11: 1MEG; R_0402; MPN RC0402FR-071ML
R12: 150K; R_0402; MPN RC0402JR-07150KL
R13, R16: 22; R_0402; MPN RC0402FR-0722RL
R25: 100K; R_0402; MPN RC0402FR-07100KL
R41: 470; R_0402; MPN RC0402JR-07470RL
U1: TPS63020; MPN TPS63020DSJ
U2: eSIM; DFN-8-1EP_6x5mm_Pitch1.27mm_SmallFlag; MPN eSIM
U3: SARA-U260; SARA-G3-U2; MPN SARA-U260-00S
U4: SIM-CARD-HOLDER; SIM8050-6-0-14-01-A; MPN SIM8050-6-0-14-01-A

Connections:
3.8V: C7.1, C9.1, C12.1, C13.1, C14.1, J1.2, L3.1, R5.1, R11.1, R20.1, R40.2, R41.2, U1.4 (VOUT), U1.5 (VOUT)
/(U1.A1)PWM0A: P1.36
/(U1.A2)PRU-0.1: P1.33
/(U1.A3)PRU-0.4: P1.31
/(U1.A4)SPI1.CS: P2.31
/(U1.A8)AIN0~1.8V: P1.19
/(U1.A10)I2C2.SCL: P1.28
/(U1.A11)I2C1.SDA: P2.11
/(U1.A12)UART0.RX: P1.32
/(U1.A13)SPI0.CLK: P1.8
/(U1.A14)SPI0.CS: P1.6
/(U1.B1)PRU-0.3: P2.30
/(U1.B2)PRU-0.2: P2.32
/(U1.B3)PRU-0.5: P2.34
/(U1.B4)PRU-0.16: P1.20
/(U1.B6)AIN2~1.8V: P1.23
/(U1.B7)VREF+: P1.18
/(U1.B8)AIN1~1.8V: P1.21
/(U1.B9)VREF-: P1.17
/(U1.B10)I2C2.SDA: P1.26
/(U1.B11)I2C1.SCL: P2.9
/(U1.B12)UART0.TX: P1.30
/(U1.B13)SPI0.MISO: P1.10
/(U1.B14)SPI0.MOSI: P1.12
/(U1.C3)PRU-0.6: P2.28
/(U1.C4)PRU-0.7: P1.29
/(U1.C5)SPI1.CLK: P2.29
/(U1.C6)AIN3~1.8V: P1.25
/(U1.C7)AIN4~1.8V: P1.27
/(U1.C12)SPI1.MISO: P2.27
/(U1.C13)SPI1.MOSI: P2.25
/(U1.E1): P1.4
/(U1.F1): P1.35
/(U1.F2)AIN6~3.3V: P1.2
/(U1.F3)AIN5~3.3V: P2.35
/(U1.L14)USB1.ID: P1.13, R19.2
/(U1.L15)USB1.D+: P1.11, R17.2
/(U1.L16)USB1.D-: P1.9, R18.2
/(U1.M14)USB1.DRVVBUS: P1.3
/(U1.M15)USB1.VBUS: P1.5
/(U1.N13)AIN7~1.8V: P2.36
/(U1.N14): P2.8
/(U1.P5)GPIO-0.23: P2.3, Q7.3 (D), R46.1
/(U1.P6): P2.24
/(U1.P7)PRU-0.15: P2.18
/(U1.P12)PWM1A: P2.1, Q8.3 (D), R47.1
/(U1.P15)UART4.RX: P2.5, Q5.3 (D), R42.1
/(U1.R5)GPIO-0.26: P1.34
/(U1.R6): P2.33
/(U1.R7): P2.20
/(U1.R11)RESET#: P2.26
/(U1.R13): P2.10
/(U1.R15): P2.4
/(U1.R16)UART4.TX: P2.7, Q6.3 (D), R43.1
/(U1.T5): P2.19
/(U1.T6)PRU-0.14: P2.22
/(U1.T7): P2.17
/(U1.T11)PWR.BTN: P2.12
/(U1.T15): P2.6
/(U1.T16): P2.2
/BAT.TEMP: P2.16
/EXT_5V: D7.2 (A), J2.2
/GPIO1: R1.2, U3.16 (GPIO1)
/GPIO2: R14.2, U3.23 (GPIO2)
/GPIO3: U3.24 (GPIO3)
/GPIO4: U3.25 (GPIO4)
/HV: C27.1, R8.2, R29.2, R42.2, R43.2, R46.2, R47.2
/LV: C21.1, Q5.1 (G), Q6.1 (G), Q7.1 (G), Q8.1 (G), R6.2, R7.2, R9.2, R44.2, R45.2
/SIM_DET: U3.42 (SIM_DET)
/UBLOX_1.8V_SUPPLY: R9.1, U3.4 (V_INT)
/UBLOX_CTS: Q8.2 (S), R45.1, U3.11 (CTS)
/UBLOX_PWR_ON: R21.1, R25.2, U3.15 (PWR_ON)
/UBLOX_RESET_N: C15.1, R22.2, U3.18 (RESET_N)
/UBLOX_RTS: Q7.2 (S), R44.1, U3.10 (RTS)
/UBLOX_RXD: Q6.2 (S), R7.1, U3.13 (RXD)
/UBLOX_SARA_USB_D_N: R16.1, R18.1, U3.28 (USB_D-)
/UBLOX_SARA_USB_D_P: R13.1, R17.1, U3.29 (USB_D+)
/UBLOX_SIM_CLK: C19.2, D11.1 (A1), U2.6 (CLK), U3.38 (SIM_CLK), U4.3 (CCCLK)
/UBLOX_SIM_IO: C18.2, D12.1 (A1), U2.3 (I/O), U3.39 (SIM_IO), U4.7 (CCIO)
/UBLOX_SIM_RST: C20.2, D10.1 (A1), U2.7 (RST), U3.40 (SIM_RST), U4.2 (CCRST)
/UBLOX_SIM_VSIM: C16.2, C17.2, D13.1 (A1), U2.8 (VCC), U3.41 (VSIM), U4.1 (CCVCC), U4.6 (CCVPP)
/UBLOX_TXD: Q5.2 (S), R6.1, U3.12 (TXD)
/UBLOX_VCC: C22.1, C23.1, C24.1, C25.1, C26.1, L3.2, U3.51 (VCC), U3.52 (VCC), U3.53 (VCC)
GND: ANT1.2 (GND), ANT1.3 (GND), ANT1.4 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.1, C17.1, C18.1, C19.1, C20.1, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, D2.2 (A2), D3.2 (A2), D4.2 (A2), D10.2 (A2), D11.2 (A2), D12.2 (A2), D13.2 (A2), J1.1, J2.1, J3.5 (GND), P1.15, P1.16, P1.22, P2.15, P2.21, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q4.2 (E), R4.1, R10.1, R12.2, R15.1, R19.1, R21.2, R23.2, R24.2, R26.2, R27.2, U1.2 (GND), U1.13 (PS/SYNC), U1.15 (PGND), U2.1 (GND), U3.1 (GND), U3.3 (GND), U3.5 (GND), U3.14 (GND), U3.20 (GND), U3.21 (GND), U3.22 (GND), U3.30 (GND), U3.32 (GND), U3.33 (RSVD), U3.43 (GND), U3.50 (GND), U3.54 (GND), U3.55 (GND), U3.57 (GND), U3.58 (GND), U3.59 (GND)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
unnamed: ANT1.1, U3.56 (ANT)
unnamed: C2.1, U1.1 (VINA), U1.12 (EN)
unnamed: C3.1, C4.1, C5.1, Q1.1 (B), R1.1
unnamed: C6.1, D2.1 (A1), J3.1 (VBUS), L2.1
unnamed: C8.1, C10.1, C11.1, Q2.1 (B), R14.1
unnamed: D1.1 (K), Q1.3 (C)
unnamed: D1.2 (A), R5.2
unnamed: D3.1 (A1), J3.3 (D+), R13.2
unnamed: D4.1 (A1), J3.2 (D-), R16.2
unnamed: D5.2 (A), R2.1
unnamed: D6.2 (A), R3.1
unnamed: D8.2 (A), L2.2
unnamed: D9.1 (K), Q2.3 (C)
unnamed: D9.2 (A), R20.2
unnamed: J3.4 (ID), R15.2
unnamed: J3.6 (Shield), R4.2
unnamed: L1.1, U1.8 (L1), U1.9 (L1)
unnamed: L1.2, U1.6 (L2), U1.7 (L2)
unnamed: Q3.1 (B), R39.1
unnamed: Q3.3 (C), Q4.1 (B), R40.1
unnamed: Q4.3 (C), R41.1
unnamed: R10.2, U1.14 (PG)
unnamed: R11.2, R12.1, U1.3 (FB)
unnamed: R22.1, R25.1, U3.2 (V_BCKP)
unnamed: R23.1, U3.6 (DSR)
unnamed: R24.1, U3.8 (DCD)
unnamed: R26.1, U3.9 (DTR)
unnamed: R27.1, U3.7 (RI)
unnamed: R28.1, U3.17 (VUSB_DET/RSVD)
unnamed: R34.2, U3.35 (I2S_TXD)
unnamed: R35.2, U3.37 (I2S_RXD)
unnamed: R36.2, U3.36 (I2S_CLK)
unnamed: R37.2, U3.34 (I2S_WA)
unnamed: R38.2, U3.19 (CODEC_CLK/RSVD)
SYS_5V_BOT: P1.24
SYS_5V_TOP: P2.13
USB_DC: P1.7, R3.2
VCC: C1.1, D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), R8.1, R28.2, R39.2, U1.10 (VIN), U1.11 (VIN)
VDD_3V3B_BOT: P1.14
VDD_3V3B_TOP: P2.23, R29.1
VDD_5V: P1.1, R2.2
VIN.BAT: P2.14

Notes on the sheet:
Power Inputs
Serial Level Translation
LEDs
uBlox u260/u201 Modem
SIM Card Holder / eSIM
Power Conversion
Beagle Pocket Pin Connections
Power Conditioning/Filtering
Discharge Circuit
Power Bypass

Board: 4 copper layers, 55.0 x 35.0 mm, 104 parts (0 on the bottom side), 66 nets.

File KiCAD/beaglephone-pocket-BOM.csv:

Refs,Qty,Link,MPN,datasheet,footprint,value
ANT1,1,https://www.digikey.com/product-detail/en/amphenol-rf-divisi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,A-1JB,,beaglephone-pocket:A-1JB,A-1JB
C1,1,https://www.digikey.com/product-detail/en/murata-electronics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,GRM188R60J106ME84D,,Capacitors_SMD:C_0603,10u
"C3-C5, C8, C10, C11, C15",7,NULL,NULL,,Capacitors_SMD:C_0402,NOPE
"C7, C9, C12, C21, C27",5,https://www.digikey.com/product-detail/en/murata-electronics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,GRM188R60J226MEA0D,,Capacitors_SMD:C_0603,22U
"C13, C14, C22",3,https://www.digikey.com/product-detail/en/avx-corporation/F9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,F950J337MBAAQ2,,Capacitors_SMD:C_1210,330U
C16,1,https://www.digikey.com/product-detail/en/samsung-electro-me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,CL05B104KO5NNNC,,Capacitors_SMD:C_0402,0.1U
C17-C20,4,https://www.digikey.com/product-detail/en/murata-electronics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,GRM1555C1H470JA01,,Capacitors_SMD:C_0402,47p
C2,1,https://www.digikey.com/product-detail/en/murata-electronics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,GRM155R61C104KA88D,,Capacitors_SMD:C_0402,100n
C23,1,https://www.digikey.com/product-detail/en/murata-electronics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,GRM1555C1H100JA01D,,Capacitors_SMD:C_0402,10n
C24,1,https://www.digikey.com/product-detail/en/murata-electronics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,GRM155R71C104KA88J,,Capacitors_SMD:C_0402,100n
C25,1,https://www.digikey.com/product-detail/en/murata-electronics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,GRM1555C1H560JA01D,,Capacitors_SMD:C_0402,56p
C26,1,https://www.digikey.com/product-detail/en/murata-electronics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,GJM1555C1H150JB01D,,Capacitors_SMD:C_0402,15p
C6,1,https://www.digikey.com/product-detail/en/samsung-electro-me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,CL10A225MQ8NNNC,,Capacitors_SMD:C_0603,2.2U
D1,1,https://www.digikey.com/product-detail/en/vishay-semiconduct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,VLMS1500-GS08,,LEDs:LED_0402,Red LED
"D2-D4, D10-D13",7,https://www.digikey.com/product-detail/en/littelfuse-inc/PES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,PESD0402-140,,Resistors_SMD:R_0402,PESD0402
D5-D8,4,https://www.digikey.com/product-detail/en/on-semiconductor/M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,MBR0520LT1G,,Diodes_SMD:D_SOD-123,MBR052
D9,1,https://www.digikey.com/product-detail/en/vishay-semiconduct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,VLMB1500-GS08,,LEDs:LED_0402,Blue LED
"J1, J2",2,https://www.digikey.com/product-detail/en/wurth-electronics-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,61300211121,,Pin_Headers:Pin_Header_Straight_1x02_Pitch2.54mm,Conn_01x02
J3,1,https://www.digikey.com/product-detail/en/amphenol-fci/10118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,10118192-0001LF,,Connectors:USB_Micro-B,USB_OTG
L1,1,http://www.mouser.com/ProductDetail/Coilcraft/XFL4020-102MEC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,XFL4020-102MEC,http://www.mouser.com/ds/2/597/xfl4020-270756.pdf,beaglephone-pocket:XFL4020,1uH
L2,1,NULL,NULL,,Inductors_SMD:L_0402,NOPE
L3,1,https://www.digikey.com/product-detail/en/murata-electronics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,BLM18AG121SN1D,,Resistors_SMD:R_0603,FB
"P1, P2",2,,PocketBeagle_Connectors,,PocketBeagle.pretty:TH-2X18-(35MIL-DIA)-W_O-SILK,PB_CONN
Q1-Q4,4,https://www.digikey.com/product-detail/en/on-semiconductor/M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,MMBT3904LT1G,,TO_SOT_Packages_SMD:SOT-23,2N3904
Q5-Q8,4,https://www.digikey.com/product-detail/en/central-semiconduc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,CMUDM7004 TR,https://www.centralsemi.com/get_document.php?cmp=1&mergetype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,beaglephone-pocket:SOT-523,Q_NMOS_GSD
"R1, R6, R7, R14, R39, R40, R42-R47",12,https://www.digikey.com/product-detail/en/yageo/RC0402JR-071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,RC0402JR-0710KL,,Resistors_SMD:R_0402,10K
"R10, R17-R19, R21-R24, R27, R34-R38",14,NULL,NULL,,Resistors_SMD:R_0402,NOPE
R11,1,https://www.digikey.com/product-detail/en/yageo/RC0402FR-071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,RC0402FR-071ML,,Resistors_SMD:R_0402,1MEG
R12,1,https://www.digikey.com/product-detail/en/yageo/RC0402JR-071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,RC0402JR-07150KL,,Resistors_SMD:R_0402,150K
"R13, R16",2,https://www.digikey.com/product-detail/en/yageo/RC0402FR-072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,RC0402FR-0722RL,,Resistors_SMD:R_0402,22
"R2-R4, R8, R9, R15, R26, R28",8,https://www.digikey.com/product-detail/en/yageo/RC0402JR-070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,RC0402JR-070RL,,Resistors_SMD:R_0402,0
"R5, R20",2,https://www.digikey.com/product-detail/en/yageo/RC0402JR-073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,RC0402JR-073KL,,Resistors_SMD:R_0402,3K
R25,1,https://www.digikey.com/product-detail/en/yageo/RC0402FR-071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,RC0402FR-07100KL,,Resistors_SMD:R_0402,100K
R41,1,https://www.digikey.com/product-detail/en/yageo/RC0402JR-074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,RC0402JR-07470RL,,Resistors_SMD:R_0402,470
U1,1,https://www.digikey.com/product-detail/en/texas-instruments/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,TPS63020DSJ,,beaglephone-pocket:TPS63020,TPS63020
U2,1,,eSIM,,Housings_DFN_QFN:DFN-8-1EP_6x5mm_Pitch1.27mm_SmallFlag,eSIM
U3,1,https://www.digikey.com/product-detail/en/u-blox-america-inc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,SARA-U260-00S,,beaglephone-pocket:SARA-G3-U2,SARA-U260
U4,1,http://www.newark.com/global-connector-technology/sim8050-6-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,SIM8050-6-0-14-01-A,http://www.farnell.com/datasheets/2342939.pdf,beaglephone-pocket:SIM8050-6-0-14-01-A,SIM-CARD-HOLDER

## Commit log

2017-09-28 Initial commit of project, derived from the BeaglePocket
2017-09-29 Added symbols for the u260 and sim holder
2017-09-29 Added footprint and modified symbol for ublox module
2017-09-29 Added grounded unit b on schematic
2017-10-10 Added SIM card holder
2017-10-11 Added more signal names using Nova schematic
2017-10-11 Stored Nova schematic rev J in the docs folder for reference
2017-10-11 Sectioned schematic into functional areas, added power converter from the Nova
2017-10-12 More connections
2017-10-12 Initial assignment of reference designators
2017-10-12 Finished initial part association, started layout
2017-10-12 Added top side gnd plane
2017-10-12 Initial routing for SIM card holders
2017-10-12 Routed LEDs
2017-10-12 Added discharge circuit from Nova
2017-10-12 Swapped pin for CTS to GPIO110
2017-10-12 Added level translation for serial pins
2017-10-12 All parts roughly placed within board boundary
2017-10-13 A few more placements
2017-10-13 Started power supply layout, added datasheet to docs
2017-10-13 More power layout
2017-10-13 Swapped SIM holder/eSIM and removed jumpers
2017-10-13 Changed TPS63020 footprint to use .3mm drills
2017-10-13 Finalized copper under TPS part
2017-10-13 Routed power on signals for ublox chip
2017-10-13 routed level translate lines
2017-10-13 Routed all Serial lines
2017-10-13 Decided to switch from UART1 to UART4
2017-10-13 Changed pin assignments
2017-10-13 Routed UART4 lines via the level translators
2017-10-14 Finished routing power for uBlox module
2017-10-14 Marked NC pins on BB header
2017-10-14 Finished most traces, started tying ground planes together
2017-10-14 Adjusted text for front side silk
2017-10-14 Back side silk
2017-10-14 Cleaned up DRC errors, including re-doing the TPS63020 part footprint
2017-10-14 Made 3v3B and SYS_5V unique names to remove 'unconnected pins' error
2017-10-14 More via stitching
2017-10-14 Finished via stitching
2017-10-14 Re-ran USB lines as differential pairs
2017-10-14 Added logos
2017-10-14 Finished cleaning up DRC errors
2017-10-14 Silkscreen touchup
2017-10-14 Generated gerbers
2017-10-14 Moved text for RX/TX
2017-10-15 Added images and readme doc
2017-10-15 Changed img URL
2017-10-15 Changed link
2017-10-17 Updated fields in BOM using KiField
2017-10-17 Generate grouped BOM using KiField
2017-11-20 Changed SOT523 footprint
2017-11-24 Added/updated some files for assembly
2017-11-24 Re-added library after moving directories and replaced SOT523 with SOT23 for mosfets
2017-11-24 Swapped pins on 2n3904 parts
2017-11-25 Moved SOT23 parts into place, changed version number, moved logo on silkscreen
2017-11-25 Started routing new sot23 level translators
2017-12-01 Finished placing SOT23 parts
2017-12-01 Final silkscreen movements
2017-12-01 Send v1.1 off to fab
2018-01-30 Added CircuitPython sketch
2018-02-16 Remove non-hologram docs
